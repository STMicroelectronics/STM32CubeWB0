# IAR project PKA_ModularExponentiation.ewp, settings and files
configuration PKA_ModularExponentiation (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB09KE ST STM32WB09KE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NUCLEO_WB09KE; USE_HAL_DRIVER; STM32WB09
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PKA_ModularExponentiation.hex
  ILINK.IlinkOutputFile: PKA_ModularExponentiation.out
  ILINK.IlinkIcfFile: stm32wb09_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User
    ../Src/: main.c stm32wb0x_hal_msp.c stm32wb0x_it.c plaintext.c ciphertext.c rsa_priv_2048.c rsa_pub_2048.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WB0x-nucleo
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_cortex.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_rng.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wb0x.c
