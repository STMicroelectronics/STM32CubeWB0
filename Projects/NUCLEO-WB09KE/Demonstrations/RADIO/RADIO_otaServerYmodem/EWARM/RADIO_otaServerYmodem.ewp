# IAR project RADIO_otaServerYmodem.ewp, settings and files
configuration RADIO_otaServerYmodem (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB09KE ST STM32WB09KE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WB09KE; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../Common/BLE/Modules; ../../../../../Common/BLE/Modules/RTDebug; ../System/Config/Debug_GPIO; ../System/Modules; ../../../../../Common/BLE/Startup; ../../../../../Common/BLE/Interfaces
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_otaServerYmodem.hex
  ILINK.IlinkOutputFile: RADIO_otaServerYmodem.out
  ILINK.IlinkIcfFile: stm32wb09_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: app_entry.c blue_unit_conversion.s main.c radio_ota.c stm32wb0x_hal_msp.c stm32wb0x_it.c ymodem.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Modules
    ../System/Modules/: clock.c gp_timer.c
  group Common/BLE/Interfaces
    ../../../../../Common/BLE/Interfaces/: stm32_lpm_if.c
  group Common/BLE/Modules
    ../../../../../Common/BLE/Modules/: osal.c
  group Common/BLE/Modules/RTDebug
    ../../../../../Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Startup
    ../../../../../Common/BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB09KE
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_cortex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c stm32wb0x_ll_rcc.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
