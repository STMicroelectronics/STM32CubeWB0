# Keil uVision project USART_Communication_Rx_IT_Continuous_Init.uvprojx, settings and files
target USART_Communication_Rx_IT_Continuous_Init (6140001::V6.14.1::ARMCLANG)
  device: STM32WB09KEVxT STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x10040000-0x100BFFFF) IROM2(0x10000000-0x100017FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: USART_Communication_Rx_IT_Continuous_Init +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=32000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ART_ACCELERATOR_ENABLE=0,STM32WB09,CFG_HW_RCC_HSE_CAPACITOR_TUNE=32
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Drivers/CMSIS/Include
  asm misc: -x assembler-with-cpp
  scatter file: stm32wb09_flash.sct
  link misc: --diag_suppress L6312W
--diag_suppress L6314W
--diag_suppress L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb09.s
  group Application/User
    ../Src/: main.c stm32wb0x_it.c
  group Doc
    ../: README.md
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_ll_utils.c stm32wb0x_ll_gpio.c stm32wb0x_ll_pwr.c stm32wb0x_ll_usart.c stm32wb0x_ll_rcc.c stm32wb0x_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32wb0x.c
software components: CMSIS:CORE 4.3.0
