# IAR project BLE_TransparentMode_C_O.ewp, settings and files
configuration BLE_TransparentMode_C_O (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB09KE ST STM32WB09KE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NUCLEO_WB09KE; BLESTACK_CONTROLLER_ONLY=1; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../System/Config/Debug_GPIO; ../System/Interfaces; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Projects/Common/BLE/Interfaces; ../../../../../../Projects/Common/BLE/Modules; ../../../../../../Projects/Common/BLE/Modules/RTDebug; ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc; ../../../../../../Projects/Common/BLE/Modules/Profiles/Inc; ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc; ../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc; ../../../../../../Projects/Common/BLE/Modules/Flash; ../../../../../../Projects/Common/BLE/Startup; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_TransparentMode_C_O.hex
  ILINK.IlinkOutputFile: BLE_TransparentMode_C_O.out
  ILINK.IlinkIcfFile: stm32wb09_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c adv_buff_alloc_tiny.c board_cmd.c dm_alloc.c dtm_burst.c dtm_cmd_db.c dtm_cmds.c dtm_preprocess_events.c fifo.c hci_parser.c pawr_buff_alloc.c transport_layer.c
  group Common/BLE/Interface
    ../../../../../../Projects/Common/BLE/Interfaces/: stm32_lpm_if.c hw_rng.c hw_pka.c hw_aes.c cryptolib_hw_aes.c
  group Common/BLE/Modules
    ../../../../../../Projects/Common/BLE/Modules/: stm_list.c osal_memcpy.s osal.c miscutil.c blue_unit_conversion.s
  group Common/BLE/Modules/RTDebug
    ../../../../../../Projects/Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/Profiles
    ../../../../../../Projects/Common/BLE/Modules/Profiles/Src/: gatt_profile.c gap_profile.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../../Projects/Common/BLE/Modules/NVMDB/Src/: nvm_db_conf.c nvm_db.c
  group Common/BLE/Modules/Flash
    ../../../../../../Projects/Common/BLE/Modules/Flash/: flash_manager.c flash_driver.c
  group Common/BLE/Startup
    ../../../../../../Projects/Common/BLE/Startup/: device_context_switch.c cpu_context_switch.s
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB09KE
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rng.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack_controller_only.a
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
