<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_StaticStack_ota.ewp</path>
  </project>
  <batchBuild />
</workspace>
