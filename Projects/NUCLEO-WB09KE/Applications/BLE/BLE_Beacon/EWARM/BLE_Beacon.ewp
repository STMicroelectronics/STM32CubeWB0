# IAR project BLE_Beacon.ewp, settings and files
configuration BLE_Beacon (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB09KE ST STM32WB09KE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NUCLEO_WB09KE; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../System/Config/Debug_GPIO; ../System/Interfaces; ../System/Modules; ../System/Modules/Flash; ../System/Modules/NVMDB/Inc; ../System/Modules/PKAMGR/Inc; ../System/Modules/Profiles/Inc; ../System/Modules/RADIO_utils/Inc; ../System/Modules/RTDebug; ../System/Startup; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Beacon.hex
  ILINK.IlinkOutputFile: BLE_Beacon.out
  ILINK.IlinkIcfFile: stm32wb09_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: eddystone_tlm_service.c eddystone_uid_service.c eddystone_url_service.c ibeacon_service.c app_ble.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c usart_if.c
  group Application/User/System/Modules
    ../System/Modules/: blue_unit_conversion.s osal_memcpy.s miscutil.c osal.c stm_list.c
  group Application/User/System/Modules/PKAMGR
    ../System/Modules/PKAMGR/Src/: pka_manager.c
  group Application/User/System/Modules/RADIO_utils
    ../System/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c
  group Application/User/System/Modules/Profiles
    ../System/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Application/User/System/Modules/Flash
    ../System/Modules/Flash/: flash_driver.c flash_manager.c
  group Application/User/System/Modules/NVMDB
    ../System/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB09KE
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rng.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
