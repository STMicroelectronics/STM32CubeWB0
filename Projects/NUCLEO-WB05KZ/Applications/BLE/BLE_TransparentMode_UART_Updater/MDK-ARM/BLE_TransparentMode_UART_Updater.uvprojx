# Keil uVision project BLE_TransparentMode_UART_Updater.uvprojx, settings and files
target BLE_TransparentMode_UART_Updater (6210000::V6.21::ARMCLANG)
  device: STM32WB05KZVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x10040000-0x1006FFFF) IROM2(0x10000000-0x100017FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: BLE_TransparentMode_UART_Updater +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NUCLEO_WB05KZ,CONFIG_NO_HCI_COMMANDS,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32WB05,UART_INTERFACE,CONFIG_HW_SMPS_10uH
  c misc: -fshort-enums
  c include: ../Core/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../../../../../../Drivers/CMSIS/Include;..\..\BLE_TransparentMode_UART_for_Updater\Core\Inc
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x30000
  memory RVCT5: ROM 0x10000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: stm32wb05_flash.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=4096 "
--diag_suppress L6312W
--diag_suppress L6314W
--diag_suppress L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb05.s
  group Application/User/Core
    ../Core/Src/: main.c updater.c updater_boot.c
  group Doc
    ../: README.md
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rng.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
software components: CMSIS:CORE 4.3.0
