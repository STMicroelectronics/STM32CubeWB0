# Keil uVision project BLE_TransparentMode_SPI_for_Updater_C_O.uvprojx, settings and files
target BLE_TransparentMode_SPI_for_Updater_C_O (6210000::V6.21::ARMCLANG)
  device: STM32WB05KZVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x80000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_TransparentMode_SPI_for_Updater_C_O +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER USE_FULL_LL_DRIVER STM32WB05 NUCLEO_WB05KZ BLESTACK_CONTROLLER_ONLY=1
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0x/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../System/Config\Debug_GPIO;../System/Interfaces;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../../../../../../Utilities/sequencer;../../../../../../Utilities/misc;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/trace/adv_trace;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc;../../../../../../Projects/Common/BLE/Interfaces;../../../../../../Projects/Common/BLE/Modules;../../../../../../Projects/Common/BLE/Modules/RTDebug;../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc;../../../../../../Projects/Common/BLE/Modules/Profiles/Inc;../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc;../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc;../../../../../../Projects/Common/BLE/Modules/Flash;../../../../../../Projects/Common/BLE/Startup
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb05_flash.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
  group Application/MDK-ARM
    ./: startup_stm32wb05.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c app_ble.c board_cmd.c dm_alloc.c dtm_burst.c dtm_cmd_db.c dtm_cmds.c dtm_preprocess_events.c fifo.c hci_parser.c pawr_buff_alloc.c transport_layer.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Common/BLE/Interface
    ../../../../../../Projects/Common/BLE/Interfaces/: stm32_lpm_if.c hw_rng.c hw_pka.c hw_aes.c cryptolib_hw_aes.c
  group Common/BLE/Modules
    ../../../../../../Projects/Common/BLE/Modules/: stm_list.c osal_memcpy.s osal.c miscutil.c blue_unit_conversion.s
  group Common/BLE/Modules/RTDebug
    ../../../../../../Projects/Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/Profiles
    ../../../../../../Projects/Common/BLE/Modules/Profiles/Src/: gatt_profile.c gap_profile.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../../Projects/Common/BLE/Modules/NVMDB/Src/: nvm_db_conf.c nvm_db.c
  group Common/BLE/Modules/Flash
    ../../../../../../Projects/Common/BLE/Modules/Flash/: flash_manager.c flash_driver.c
  group Common/BLE/Startup
    ../../../../../../Projects/Common/BLE/Startup/: device_context_switch.c cpu_context_switch.s
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WB0x-nucleo
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_crc.c stm32wb0x_hal_crc_ex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_i2s.c stm32wb0x_hal_irda.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_smartcard.c stm32wb0x_hal_smartcard_ex.c stm32wb0x_hal_smbus.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c stm32wb0x_hal_usart.c stm32wb0x_hal_usart_ex.c stm32wb0x_ll_spi.c stm32wb0x_ll_gpio.c
  group Middlewares/STM32_BLE/queued_writes
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
  group Middlewares/STM32_BLE/cryptolib
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack_controller_only.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
