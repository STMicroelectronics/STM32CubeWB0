# IAR project BLE_TransparentMode_SPI_for_Updater_C_O.ewp, settings and files
configuration BLE_TransparentMode_SPI_for_Updater_C_O (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB05KZ ST STM32WB05KZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WB05KZ; BLESTACK_CONTROLLER_ONLY=1; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB05
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0x/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../System/Config\Debug_GPIO; ../System/Interfaces; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Projects/Common/BLE/Interfaces; ../../../../../../Projects/Common/BLE/Modules; ../../../../../../Projects/Common/BLE/Modules/RTDebug; ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc; ../../../../../../Projects/Common/BLE/Modules/Profiles/Inc; ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc; ../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc; ../../../../../../Projects/Common/BLE/Modules/Flash; ../../../../../../Projects/Common/BLE/Startup; ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/misc; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_TransparentMode_SPI_for_Updater_C_O.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: BLE_TransparentMode_SPI_for_Updater_C_O.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=4096
  ILINK.IlinkIcfFile: stm32wb05_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb05.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c adv_buff_alloc_tiny.c app_ble.c board_cmd.c dm_alloc.c dtm_burst.c dtm_cmd_db.c dtm_cmds.c dtm_preprocess_events.c fifo.c hci_parser.c pawr_buff_alloc.c transport_layer.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Common/BLE/Interface
    ../../../../../Common/BLE/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c
  group Common/BLE/Modules
    ../../../../../Common/BLE/Modules/: blue_unit_conversion.s miscutil.c osal.c osal_memcpy.s stm_list.c
  group Common/BLE/Modules/Flash
    ../../../../../Common/BLE/Modules/Flash/: flash_driver.c flash_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../Common/BLE/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/Profiles
    ../../../../../Common/BLE/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/RTDebug
    ../../../../../Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Startup
    ../../../../../Common/BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB05KZ
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_crc.c stm32wb0x_hal_crc_ex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_i2s.c stm32wb0x_hal_irda.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_smartcard.c stm32wb0x_hal_smartcard_ex.c stm32wb0x_hal_smbus.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c stm32wb0x_hal_usart.c stm32wb0x_hal_usart_ex.c stm32wb0x_ll_dma.c stm32wb0x_ll_gpio.c stm32wb0x_ll_spi.c stm32wb0x_ll_utils.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack_controller_only.a
  group Middlewares/STM32_BLE/cryptolib
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
  group Middlewares/STM32_BLE/queued_writes
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
