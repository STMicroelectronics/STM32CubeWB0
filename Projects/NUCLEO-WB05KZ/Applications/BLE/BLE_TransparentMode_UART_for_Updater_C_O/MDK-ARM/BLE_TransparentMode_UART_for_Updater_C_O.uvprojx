# Keil uVision project BLE_TransparentMode_UART_for_Updater_C_O.uvprojx, settings and files
target BLE_TransparentMode_UART_for_Updater_C_O (6210000::V6.21::ARMCLANG)
  device: STM32WB05KZVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x10040000-0x1006FFFF) IROM2(0x10000000-0x100017FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: BLE_TransparentMode_UART_for_Updater_C_O +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NUCLEO_WB05KZ,BLESTACK_CONTROLLER_ONLY=1,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32WB05
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../System/Config/Debug_GPIO;../System/Interfaces;..\..\..\..\..\Common\BLE\Modules;..\..\..\..\..\Common\BLE\Modules\Flash;..\..\..\..\..\Common\BLE\Modules\NVMDB\Inc;..\..\..\..\..\Common\BLE\Modules\PKAMGR\Inc;..\..\..\..\..\Common\BLE\Modules\Profiles\Inc;..\..\..\..\..\Common\BLE\Interfaces;..\..\..\..\..\Common\BLE\Modules\RADIO_utils\Inc;..\..\..\..\..\Common\BLE\Modules\RTDebug;..\..\..\..\..\Common\BLE\Startup;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x30000
  memory RVCT5: ROM 0x10000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: stm32wb05_flash.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=4096 "
  group Application/MDK-ARM
    ./: startup_stm32wb05.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Common/BLE/Startup
    ../../../../../Common/BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Common/BLE/Interfaces
    ../../../../../Common/BLE/Interfaces/: stm32_lpm_if.c cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c
  group Common/BLE/Modules
    ../../../../../Common/BLE/Modules/: blue_unit_conversion.s osal_memcpy.s miscutil.c osal.c stm_list.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/RTDebug
    ../../../../../Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules/Profiles
    ../../../../../Common/BLE/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Common/BLE/Modules/Flash
    ../../../../../Common/BLE/Modules/Flash/: flash_driver.c flash_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../Common/BLE/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c adv_buff_alloc_tiny.c board_cmd.c dm_alloc.c dtm_burst.c dtm_cmd_db.c dtm_cmds.c dtm_preprocess_events.c fifo.c hci_parser.c pawr_buff_alloc.c transport_layer.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB05KZ
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rng.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack_controller_only.a
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
