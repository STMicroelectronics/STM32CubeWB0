<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RADIO_Throughput_RXB.ewp</path>
  </project>
  <batchBuild />
</workspace>
