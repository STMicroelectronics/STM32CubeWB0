# IAR project PKA_ECDSA_Sign.ewp, settings and files
configuration PKA_ECDSA_Sign (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB05KZ ST STM32WB05KZ
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=32000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; ART_ACCELERATOR_ENABLE=0; STM32WB05; CFG_HW_RCC_HSE_CAPACITOR_TUNE=32
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PKA_ECDSA_Sign.hex
  ILINK.IlinkOutputFile: PKA_ECDSA_Sign.out
  ILINK.IlinkIcfFile: stm32wb05_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb05.s
  group Application/User
    ../Src/: main.c prime256v1.c SigGen.c stm32wb0x_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_ll_gpio.c stm32wb0x_ll_pka.c stm32wb0x_ll_pwr.c stm32wb0x_ll_rng.c stm32wb0x_ll_utils.c
