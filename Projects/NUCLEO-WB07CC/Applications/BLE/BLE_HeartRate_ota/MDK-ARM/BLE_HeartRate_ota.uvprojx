# Keil uVision project BLE_HeartRate_ota.uvprojx, settings and files
target BLE_HeartRate_ota (6210000::V6.21::ARMCLANG)
  device: STM32WB07CCVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x10040000-0x1007FFFF) IROM2(0x10000000-0x100017FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: BLE_HeartRate_ota +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NUCLEO_WB07CC,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32WB07
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../System/Config/Debug_GPIO;../System/Interfaces;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Projects/Common/BLE/Interfaces;../../../../../../Projects/Common/BLE/Modules;../../../../../../Projects/Common/BLE/Modules/RTDebug;../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc;../../../../../../Projects/Common/BLE/Modules/Profiles/Inc;../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc;../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc;../../../../../../Projects/Common/BLE/Modules/Flash;../../../../../../Projects/Common/BLE/Startup;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x1800
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb07_flash.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x1000"
--predefine="-DMEMORY_FLASH_APP_SIZE=0x1F000"
--diag_suppress L6312W
--diag_suppress L6314W
--diag_suppress L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb07.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c hrs.c hrs_app.c dis.c dis_app.c ota.c ota_app.c
  group Common/BLE/Interface
    ../../../../../../Projects/Common/BLE/Interfaces/: stm32_lpm_if.c hw_rng.c hw_pka.c hw_aes.c cryptolib_hw_aes.c
  group Common/BLE/Modules
    ../../../../../../Projects/Common/BLE/Modules/: stm_list.c osal_memcpy.s osal.c miscutil.c blue_unit_conversion.s
  group Common/BLE/Modules/RTDebug
    ../../../../../../Projects/Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/Profiles
    ../../../../../../Projects/Common/BLE/Modules/Profiles/Src/: gatt_profile.c gap_profile.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../../Projects/Common/BLE/Modules/NVMDB/Src/: nvm_db_conf.c nvm_db.c
  group Common/BLE/Modules/Flash
    ../../../../../../Projects/Common/BLE/Modules/Flash/: flash_manager.c flash_driver.c
  group Common/BLE/Startup
    ../../../../../../Projects/Common/BLE/Startup/: device_context_switch.c cpu_context_switch.s
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB07CC
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rng.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 5.6.0
