# Keil uVision project BLE_p2pServer_FreeRTOS.uvprojx, settings and files
target BLE_p2pServer_FreeRTOS (6210000::V6.21::ARMCLANG)
  device: STM32WB07CCVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x80000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_p2pServer_FreeRTOS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER STM32WB07 NUCLEO_WB07CC USE_FULL_LL_DRIVER
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0x/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../System/Config\Debug_GPIO;../System/Interfaces;..\..\..\..\..\..\Projects\Common\BLE\Interfaces;..\..\..\..\..\..\Projects\Common\BLE\Modules\PKAMGR\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\NVMDB\Inc;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\RADIO_utils\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\RTDebug;..\..\..\..\..\..\Projects\Common\BLE\Modules;..\..\..\..\..\..\Projects\Common\BLE\Startup;../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../../../../../../Utilities/sequencer;../../../../../../Utilities/misc;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/trace/adv_trace;..\..\..\..\..\..\Projects\Common\BLE\Modules\Profiles\Inc;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\Flash;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/AES;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/AES/CBC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/AES/CMAC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/AES/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/inc/AES/ECB;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM0
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb07_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wb07.s
  group Application/User/Core
    ../Core/Src/: app_entry.c app_freertos.c main.c stm32wb0x_hal_msp.c stm32wb0x_hal_timebase_tim.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c p2p_server.c p2p_server_app.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Common/BLE/Modules/Flash
    ../../../../../../Projects/Common/BLE/Modules/Flash/: flash_driver.c flash_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../../Projects/Common/BLE/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/Profiles
    ../../../../../../Projects/Common/BLE/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/RTDebug
    ../../../../../../Projects/Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules
    ../../../../../../Projects/Common/BLE/Modules/: blue_unit_conversion.s miscutil.c osal.c osal_memcpy.s stm_list.c
  group Common/BLE/Startup
    ../../../../../../Projects/Common/BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB07CC
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_crc.c stm32wb0x_hal_crc_ex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_i2s.c stm32wb0x_hal_irda.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_smartcard.c stm32wb0x_hal_smartcard_ex.c stm32wb0x_hal_smbus.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c stm32wb0x_hal_usart.c stm32wb0x_hal_usart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM0/: port.c
  group Middlewares/STM32_BLE/cryptolib
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
  group Middlewares/STM32_BLE/evt_handler
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
  group Middlewares/STM32_BLE/queued_writes
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
  group Common/BLE/Interface
    ../../../../../../Projects/Common/BLE/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c
