# IAR project BLE_TransparentMode_UART_Updater.ewp, settings and files
configuration BLE_TransparentMode_UART_Updater (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB07CC ST STM32WB07CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WB07CC; CONFIG_NO_HCI_COMMANDS; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB07; UART_INTERFACE; CONFIG_HW_SMPS_10uH
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo; ../../BLE_TransparentMode_UART_for_Updater/Core/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_TransparentMode_UART_Updater.hex
  ILINK.IlinkOutputFile: BLE_TransparentMode_UART_Updater.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=4096
  ILINK.IlinkIcfFile: stm32wb07_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: main.c updater.c updater_boot.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_cortex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
