# Keil uVision project BLE_Peripheral_Lite.uvprojx, settings and files
target BLE_Peripheral_Lite (6160000::V6.16::ARMCLANG)
  device: STM32WB07CCVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x10040000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Peripheral_Lite +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER STM32WB07 NUCLEO_WB07CC
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0x/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../System/Config\Debug_GPIO;../System/Interfaces;../System/Modules/PKAMGR/Inc;../System/Modules/NVMDB/Inc;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;../System/Modules/RADIO_utils/Inc;../System/Modules/RTDebug;../System/Modules;../System/Startup;../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../../../../../../Utilities/sequencer;../../../../../../Utilities/misc;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/trace/adv_trace;../System/Modules/Profiles/Inc;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb07_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wb07.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c peripheral_lite_server.c peripheral_lite_server_app.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c usart_if.c
  group Application/User/System/Modules/NVMDB
    ../System/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Application/User/System/Modules/PKAMGR
    ../System/Modules/PKAMGR/Src/: pka_manager.c
  group Application/User/System/Modules/Profiles
    ../System/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Application/User/System/Modules/RADIO_utils
    ../System/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c
  group Application/User/System/Modules
    ../System/Modules/: blue_unit_conversion.s miscutil.c osal.c osal_memcpy.s
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WB0x-nucleo
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_crc.c stm32wb0x_hal_crc_ex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_i2s.c stm32wb0x_hal_irda.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_smartcard.c stm32wb0x_hal_smartcard_ex.c stm32wb0x_hal_smbus.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c stm32wb0x_hal_usart.c stm32wb0x_hal_usart_ex.c
  group Middlewares/STM32_BLE/evt_handler
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
  group Middlewares/STM32_BLE/queued_writes
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
  group Middlewares/STM32_BLE/cryptolib
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
