<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_RC_LongRange_Central.ewp</path>
  </project>
  <batchBuild />
</workspace>
