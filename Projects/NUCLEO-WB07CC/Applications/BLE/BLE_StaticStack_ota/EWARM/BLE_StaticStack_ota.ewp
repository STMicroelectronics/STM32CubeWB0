# IAR project BLE_StaticStack_ota.ewp, settings and files
configuration BLE_StaticStack_ota (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB07CC ST STM32WB07CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WB07CC; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB07; RESET_MANAGER_SIZE=0x1C000
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../System/Config/Debug_GPIO; ../System/Interfaces; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo; ../../../../../../Projects/Common/BLE/Interfaces; ../../../../../../Projects/Common/BLE/Modules; ../../../../../../Projects/Common/BLE/Modules/RTDebug; ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc; ../../../../../../Projects/Common/BLE/Modules/Profiles/Inc; ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc; ../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc; ../../../../../../Projects/Common/BLE/Modules/Flash; ../../../../../../Projects/Common/BLE/Startup
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_StaticStack_ota.hex
  postbuild: "..\..\..\..\..\..\Utilities\create_sym_lib.exe" --symbols "..\sym_export.txt" "$TARGET_PATH$" "..\ble_static_stack_sym.a"
  ILINK.IlinkOutputFile: BLE_StaticStack_ota.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x1C000
  ILINK.IlinkIcfFile: stm32wb07_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb07.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: ble_cmd_if.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: bleplat_cntr.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_cortex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
