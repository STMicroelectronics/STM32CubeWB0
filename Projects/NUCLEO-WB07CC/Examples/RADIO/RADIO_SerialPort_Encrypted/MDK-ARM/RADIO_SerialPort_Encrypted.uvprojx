# Keil uVision project RADIO_SerialPort_Encrypted.uvprojx, settings and files
target RADIO_SerialPort_Encrypted (6210000::V6.21::ARMCLANG)
  device: STM32WB07CCVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x10040000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RADIO_SerialPort_Encrypted +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NUCLEO_WB07CC,USE_HAL_DRIVER,STM32WB07
  c misc: -fshort-enums
  c include: ../Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb07_flash.sct
  link misc: --diag_suppress L6312W
--diag_suppress L6314W
--diag_suppress L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb07.s
  group Application/User
    ../Src/: main.c blue_unit_conversion.s stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB07CC
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_cortex.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wb0x.c
software components: CMSIS:CORE 5.6.0
