# IAR project PWR_Consumption.ewp, settings and files
configuration PWR_Consumption (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB07CC ST STM32WB07CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NUCLEO_WB07CC; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB07
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../System/Config/Debug_GPIO; ../System/Interfaces; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-nucleo; ../../../../../../Projects/Common/BLE/Interfaces; ../../../../../../Projects/Common/BLE/Modules; ../../../../../../Projects/Common/BLE/Modules/RTDebug; ../../../../../../Projects/Common/BLE/Modules/RADIO_utils/Inc; ../../../../../../Projects/Common/BLE/Modules/Profiles/Inc; ../../../../../../Projects/Common/BLE/Modules/PKAMGR/Inc; ../../../../../../Projects/Common/BLE/Modules/NVMDB/Inc; ../../../../../../Projects/Common/BLE/Modules/Flash; ../../../../../../Projects/Common/BLE/Startup
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_Consumption.hex
  ILINK.IlinkOutputFile: PWR_Consumption.out
  ILINK.IlinkIcfFile: stm32wb07_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb07.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Common/BLE/Interface
    ../../../../../Common/BLE/Interfaces/: stm32_lpm_if.c
  group Common/BLE/Modules
    ../../../../../Common/BLE/Modules/: blue_unit_conversion.s miscutil.c osal.c osal_memcpy.s stm_list.c
  group Common/BLE/Modules/RTDebug
    ../../../../../Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Startup
    ../../../../../Common/BLE/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB07CC
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_cortex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
