<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PWR_Consumption.ewp</path>
  </project>
  <batchBuild />
</workspace>
