<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RADIO_SleepRx.ewp</path>
  </project>
  <batchBuild />
</workspace>
